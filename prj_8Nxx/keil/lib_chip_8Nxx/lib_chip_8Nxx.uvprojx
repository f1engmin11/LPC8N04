# Keil uVision project lib_chip_8Nxx.uvprojx, settings and files
target lib_chip_8Nxx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC8N04FHI24 NXP
  pack: Keil.LPC8N04_DFP.1.0.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00007800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_chip_8Nxx (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS, DEBUG
  c include: ..\..\..\lib_chip_8Nxx\inc;..\..\..\lib_chip_8Nxx\mods;..\..\..\lib_chip_8Nxx\mods\startup
  memory RVCT4: ROM 0x0 size 0x7800
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../lib_chip_8Nxx/src/: bussync_8Nxx.c clock_8Nxx.c eeprom_8Nxx.c flash_8Nxx.c gpio_8Nxx.c i2c_8Nxx.c iap_8Nxx.c iocon_8Nxx.c nfc_8Nxx.c pmu_8Nxx.c rtc_8Nxx.c ssp_8Nxx.c syscon_8Nxx.c timer_8Nxx.c tsen_8Nxx.c wwdt_8Nxx.c
