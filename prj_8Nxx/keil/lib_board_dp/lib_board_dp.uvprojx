# Keil uVision project lib_board_dp.uvprojx, settings and files
target lib_board_8Nxx (ARM-ADS)
  device: LPC8N04FHI24 NXP
  pack: Keil.LPC8N04_DFP.1.0.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00007800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_board_8Nxx (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS, DEBUG
  c include: ..\..\..\lib_chip_8Nxx\inc;..\..\..\lib_board_dp\inc;..\..\..\lib_board_dp\mods;..\..\..\lib_board_dp\mods\led
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x7800
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../lib_board_dp/src/: board.c
    ../../../lib_board_dp/mods/led/: led.c
