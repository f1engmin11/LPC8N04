# Keil uVision project app_demo.uvprojx, settings and files
target iflash_lpc8Nxx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC8N04FHI24 NXP
  pack: Keil.LPC8N04_DFP.1.0.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00007800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: app_demo +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: $K\ARM\ARMCC\BIN\FROMELF.EXE --bin --output keil_output\app_demo.bin keil_output\app_demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS, DEBUG
  c include: ..\..\..\app_demo\inc;..\..\..\app_demo\src;..\..\..\app_demo\mods\ndeft2t;..\..\..\app_demo\mods\tmeas;..\..\..\lib_board_dp\inc;..\..\..\lib_board_dp\src;..\..\..\lib_chip_8Nxx\inc;..\..\..\lib_chip_8Nxx\src;..\app_demo;..\lib_board_dp;..\lib_chip_8Nxx;..\..\mcux;..\..\..\lib_board_dp\mods;..\..\..\lib_board_dp\mods\led;..\..\..\lib_chip_8Nxx\mods;..\..\..\lib_chip_8Nxx\mods\startup;..\..\..\app_demo\mods
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x7800
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../app_demo/src/: crp.c main.c timer.c
    ../../../lib_chip_8Nxx/mods/startup/: keil_startup_lpc8Nxx.s
  group libs
    ../lib_chip_8Nxx/keil_output/core_m4/: lib_chip_8Nxx.lib
    ../lib_board_dp/keil_output/core_m4/: lib_board_8Nxx.lib
