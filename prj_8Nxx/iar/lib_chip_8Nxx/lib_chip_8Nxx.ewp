# IAR project lib_chip_8Nxx.ewp, settings and files
configuration chip_8Nxx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC8N04 NXP LPC8N04
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; DEBUG
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\lib_chip_8Nxx\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0PLUS
  AARM.AUserIncludes: ..\..\..\lib_chip_8Nxx\inc
  AARM.AExtraOptionsV2: -j
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group inc
    ../../../lib_chip_8Nxx/inc/: assert.h bussync_8Nxx.h chip.h clock_8Nxx.h cmsis.h core_cm0plus.h core_cmFunc.h core_cmInstr.h eeprom_8Nxx.h flash_8Nxx.h gpio_8Nxx.h i2c_8Nxx.h iap_8Nxx.h iocon_8Nxx.h nfc_8Nxx.h pmu_8Nxx.h rtc_8Nxx.h ssp_8Nxx.h syscon_8Nxx.h timer_8Nxx.h tsen_8Nxx.h wwdt_8Nxx.h
  group src
    ../../../lib_chip_8Nxx/src/: bussync_8Nxx.c clock_8Nxx.c eeprom_8Nxx.c flash_8Nxx.c gpio_8Nxx.c i2c_8Nxx.c iap_8Nxx.c iocon_8Nxx.c nfc_8Nxx.c pmu_8Nxx.c rtc_8Nxx.c ssp_8Nxx.c syscon_8Nxx.c timer_8Nxx.c tsen_8Nxx.c wwdt_8Nxx.c
