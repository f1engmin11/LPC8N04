# IAR project app_demo.ewp, settings and files
configuration iflash_lpc8Nxx (ARM)
  General.OGChipSelectEditMenu: LPC8N04 NXP LPC8N04
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; DEBUG
  ICCARM.CCDiagSuppress: Pe161, Pa050, Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\lib_chip_8Nxx\inc; ..\..\..\lib_board_dp\inc; ..\..\..\lib_board_dp\mods; ..\..\..\lib_board_dp\mods\led; ..\..\..\app_demo\inc; ..\..\..\app_demo\mods
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: app_demo.bin
  ILINK.IlinkOutputFile: app_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group inc
    ../../../app_demo/inc/: timer.h
  group lib
    ../lib_board_dp/iar_output/Exe/: board_8Nxx.a
    ../lib_chip_8Nxx/iar_output/Exe/: chip_8Nxx_lib.a
  group mods
    ../../../app_demo/mods/: app_sel.h
    ../../../app_demo/mods/ndeft2t/: ndeft2t.c ndeft2t.h ndeft2t_dft.h
    ../../../app_demo/mods/tmeas/: tmeas.c tmeas.h tmeas_dft.h
  group src
    ../../../app_demo/src/: crp.c main.c timer.c
    ../../../lib_chip_8Nxx/mods/startup/: iar_startup_lpc8Nxx.s
