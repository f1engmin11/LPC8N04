# IAR project lib_board_dp.ewp, settings and files
configuration brd_8Nxx (ARM, debug)
  General.OGChipSelectEditMenu: LPC8N04 NXP LPC8N04
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\lib_chip_8Nxx\inc; ..\..\..\lib_board_dp\inc; ..\..\..\lib_board_dp\mods; ..\..\..\lib_board_dp\mods\led
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group inc
    ../../../lib_board_dp/inc/: board.h
  group mods
    ../../../lib_board_dp/mods/: board_sel.h
    ../../../lib_board_dp/mods/led/: led.c led.h led_dft.h
  group src
    ../../../lib_board_dp/src/: board.c
